# Keil uVision project FreeRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FreeRTOS
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\FreeRTOSv10.1.1\FreeRTOS\Source\include;.\FreeRTOSv10.1.1\FreeRTOS\Source\portable\RVDS\ARM_CM3;.\User
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./User/: main.cpp SerialPort.cpp
  group FreeRTOS
    ./FreeRTOSv10.1.1/FreeRTOS/Source/: list.c tasks.c
    ./FreeRTOSv10.1.1/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ./FreeRTOSv10.1.1/FreeRTOS/Source/portable/MemMang/: heap_4.c
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
